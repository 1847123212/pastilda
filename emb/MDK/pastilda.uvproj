# Keil uVision project pastilda.uvproj, settings and files
target pastilda (6040000::V6.4::.\ARMCLANG)
  device: STM32F205RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: pastilda
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=1
  c define: STM32F4 USE_STM32F4_USBH_DRIVER_HS STM32F20x_16 USE_RTT
  c include: ..\..\lib\libopencm3\include;..\..\lib\libopencm3\lib;..\pastilda\app;..\pastilda;..\pastilda\flash;..\pastilda\lib\libopenfat\openfat;..\pastilda\lib\libusbhost;..\pastilda\lib\libopencm3_cpp_extensions;..\pastilda\lib\libopenfat;..\MDK;..\pastilda\flash\drv;..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ./: startup_stm32f40_41xxx.s
    ../pastilda/: main.cpp
  group app
    ../pastilda/app/: app.cpp leds.cpp
  group usb/usb_device
    ../pastilda/usb/usb_device/: usbd_composite.cpp usbd_composite_desc.cpp
  group usb/usb_host
    ../pastilda/usb/usb_host/: usbh_host.cpp
  group libusbhost
    ../pastilda/lib/libusbhost/: usbh_driver_hid_kbd.c usbh_hubbed.c usbh_lld_stm32f4.c
  group libopencm3_cpp_extensions
    ../pastilda/lib/libopencm3_cpp_extensions/: gpio_ext.cpp round_buffer.cpp spi_ext.cpp systick_ext.cpp timer_ext.cpp
  group libopencm3/cm3
    ../../lib/libopencm3/lib/cm3/: systick.c nvic.c assert.c
  group libopencm3/stm32/common
    ../../lib/libopencm3/lib/stm32/common/: rcc_common_all.c gpio_common_all.c gpio_common_f0234.c flash_common_f24.c spi_common_all.c spi_common_l1f124.c flash_common_f234.c
  group libopencm3/stm32/f4
    ../../lib/libopencm3/lib/stm32/f4/: flash.c rcc.c spi.c pwr.c
    ../../lib/libopencm3/lib/stm32/common/: exti_common_all.c
  group libopencm3/usb
    ../../lib/libopencm3/lib/usb/: usb.c usb_standard.c usb_control.c usb_fx07_common.c usb_f107.c usb_f207.c usb_msc.c
  group flash
    ../pastilda/flash/: flash_memory.cpp
    ../pastilda/flash/drv/: SST25.cpp
  group RTT
    ../RTT/: HardFaultHandler.S SEGGER_HardFaultHandler.c SEGGER_RTT.c SEGGER_RTT_Conf.h SEGGER_RTT.h SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
